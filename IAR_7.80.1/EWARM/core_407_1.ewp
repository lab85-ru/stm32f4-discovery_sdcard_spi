# IAR project core_407_1.ewp, settings and files
configuration core_407_1 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VE ST STM32F407VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG=0; STM32F407xx; HSE=0; HSI=1; SPI8=1; SPI16=0
  ICCARM.CCIncludePath2: ../src/; ../src/lib; ../src/hal; ../src/ff
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Core\Inc
  OBJCOPY.OOCOutputFile: core_407_1.hex
  ILINK.IlinkOutputFile: core_407_1.out
  ILINK.IlinkIcfFile: ../src/stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../src/: board.h debug.c debug.h global_var.h hardware.c hardware.h main.c main.h printf_hal.c printf_hal.h queue_buf.c queue_buf.h queue_buf_cfg.h startup_stm32f407xx.s stm32f407xx.h stm32f4xx_it.c sys_timer.c sys_timer.h time_hal.c time_hal.h version.h xprintf.c xprintf.h
  group ff
    ../src/ff/: diskio.h ff.c ff.h ffconf.h ffsystem.c ffunicode.c mmc_spi.c spi.h
  group hal
    ../src/hal/: dma_407.c dma_407.h gpio_407.c gpio_407.h i2c_407.c i2c_407.h rcc_407.c rcc_407.h spi_407.c spi_407.h usart_407.c usart_407.h
